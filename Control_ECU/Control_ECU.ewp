# IAR project Control_ECU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Control_ECU.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Drivers/Buzzer/: buzzer.c buzzer.h tm4c123gh6pm.h
    ../Common/HAL/: comm_interface.c comm_interface.h
    ./: ECU_COMM.c
    Drivers/Eeprom/: eeprom.c eeprom.h eeprom_hw.h eeprom_hw_tm4c.c tm4c123gh6pm.h
    Drivers/startup_ewarm/: hw_nvic.h hw_types.h startup_ewarm.c
    Drivers/Motor/: motor.c motor.h
    Helpers/: timer.c timer.h
    ../Common/MCAL/: uart.c uart.h
