<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\OneDrive\Desktop\embedded.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\OneDrive\Desktop\HMI.ewp</path>
    </project>
    <batchBuild />
</workspace>
